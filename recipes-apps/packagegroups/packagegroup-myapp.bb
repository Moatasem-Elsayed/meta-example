SUMMARY = "groups for applications"
inherit packagegroup
RDEPENDS_${PN} = "\
cpp-hello-world \
python-gui \
cmake-hello-world \
login \
"
